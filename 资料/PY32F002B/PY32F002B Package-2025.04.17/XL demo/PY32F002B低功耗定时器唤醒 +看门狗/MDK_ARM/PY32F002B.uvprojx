# Keil uVision project PY32F002B.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: PY32F002Bx5 Puya
  pack: Puya.PY32F0xx_DFP.1.1.9
  cpu: IRAM(0x20000000,0x00000C00) IROM(0x08000000,0x00006000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: PY32F002B +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,PY32F002Bx5
  c include: ..\Drivers\CMSIS\Include;..\Drivers\CMSIS\Device\PY32F0xx\Include;..\Drivers\PY32F002B_HAL_Driver\Inc;..\User\Inc;..\User_Drivers\User_LED;..\User_Drivers\User_USART1;..\User_Drivers\User_System_Clock_Config;..\User_Drivers\User_LPTIM;..\User_Drivers\User_STOP_Mode;..\User_Drivers\User_IWDG
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x6000
  memory RVCT9: RAM 0x20000000 size 0xc00
  group MDK_ARM
    ../Drivers/CMSIS/Device/PY32F0xx/Source/arm/: startup_py32f002bxx.s
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/PY32F0xx/Source/: system_py32f002b.c
  group Drivers/HAL
    ../Drivers/PY32F002B_HAL_Driver/Src/: py32f002b_hal.c py32f002b_hal_adc.c py32f002b_hal_comp.c py32f002b_hal_cortex.c py32f002b_hal_crc.c py32f002b_hal_exti.c py32f002b_hal_gpio.c py32f002b_hal_i2c.c py32f002b_hal_iwdg.c py32f002b_hal_lptim.c py32f002b_hal_pwr.c py32f002b_hal_rcc.c py32f002b_hal_spi.c py32f002b_hal_tim.c py32f002b_hal_tim_ex.c py32f002b_hal_uart.c py32f002b_hal_usart.c py32f002b_hal_flash.c py32f002b_hal_rcc_ex.c
  group Code/User
    ../User/Src/: main.c py32f002b_it.c
  group Drivers/User
    ../User_Drivers/User_LED/: User_LED.c
    ../User_Drivers/User_USART1/: User_USART1.c
    ../User_Drivers/User_System_Clock_Config/: User_System_Clock_Config.c
    ../User_Drivers/User_LPTIM/: User_LPTIM.c
    ../User_Drivers/User_STOP_Mode/: User_STOP_Mode.c
    ../User_Drivers/User_IWDG/: User_IWDG.c
