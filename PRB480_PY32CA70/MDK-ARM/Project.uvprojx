# Keil uVision project Project.uvprojx, settings and files
target Project (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: PY32CA70x4 Puya
  pack: Puya.PY32CA7xx_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00000800) IROM(0x08000000,0x00004000) IROM2(0x1FFF0040,0x00000040) XROM(0x1FFF01C0,0x00000040) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: PY32CA70x4,USE_FULL_LL_DRIVER
  c include: ..\Inc;..\User_Drivers\PRB480;..\Drivers\PY32CA70_HAL_Driver\Inc;..\Drivers\BSP\PY32CA70xx_Start_Kit;..\Drivers\CMSIS\Include;..\Drivers\CMSIS\Device\PY32CA7xx\Include
  library: MicroLIB
  memory RVCT1: ROM 0x1fff01c0 size 0x40
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT5: ROM 0x1fff0040 size 0x40
  memory RVCT9: RAM 0x20000000 size 0x800
  group Common
    ../Src/: system_py32ca70.c
    ./: startup_py32ca70xx.s
  group Application/User
    ../Src/: main.c py32ca70_it.c
  group BSP/py32ca70xx_Start_Kit
    ../Drivers/BSP/PY32CA70xx_Start_Kit/: py32ca70xx_ll_Start_Kit.c
  group User_Drivers/PRB480
    ../User_Drivers/PRB480/: PRB480.c CRC16.c SHA1.c
  group Drivers/PY32CA70_HAL_Driver
    ../Drivers/PY32CA70_HAL_Driver/Src/: py32ca70_ll_adc.c py32ca70_ll_utils.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 6.1.0
